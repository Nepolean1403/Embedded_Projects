#include<lpc21xx.h>
#include<string.h>
#include"LCD_functions.h"

void CGRAM_WRITE(unsigned char);
char arr[]={
  	0x00,0x01,0x03,0x05,0x09,0x11,0x1f,0x00,
	0x00,0x01,0x03,0x05,0x09,0x19,0x1f,0x00,
	0x00,0x01,0x03,0x05,0x0d,0x1d,0x1f,0x00,
	0x00,0x01,0x03,0x07,0x0f,0x1f,0x1f,0x00,
  		   };
int main()
{
	int i=0;
 	LCD_INIT();
	CGRAM_WRITE(32);
	while(1)
	{
	while(i<4)
	{
	LCD_DATA(i);
	LCD_COMMAND(0x85);
	delay_milliseconds(1000);
	i++;
	if(i==4)
	i=0;
	}
	}
	 			
}
void CGRAM_WRITE(unsigned char n)
{
	unsigned char i;
	LCD_COMMAND(0X40);
	  for(i=0;i<n;i++)
	  LCD_DATA(arr[i]);
}
